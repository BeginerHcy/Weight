# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;.\BxHwCfg;.\CAN;.\STMFLASH;..\APP;.\DC7760;.\ADC;.\Motorky-source\inc;.\AxisRT\inc;.\CANOpenMaster;.\CanFestival-3\include;.\CanFestival-3\objdict;.\TIMER;.\Canopen;.\Modbus;.\IAP;.\Weight
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
    ./CAN/: Can.c
    ./BxHwCfg/: HwCfg.c
    ./STMFLASH/: stmflash.c
    ./ADC/: adc.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s stm32f4xx_it.c arm_cortexM4lf_math.lib system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group README
    ../README/: README.txt
  group APP
    ../APP/: BoxApp.c
    ./DC7760/: DAC7760.c
    ./IAP/: IAP.c
    ./Weight/: bsp_spiweight.c
  group Motorky
    ./Motorky-source/src/: auxiliaries.c ds.c fi.c mm.c path_generator.c sm.c speed_ramping.c
  group AxiseRT
    ./AxisRT/src/: nAxiseRT.c nOperate.c
  group CanOpen
    ./Canopen/: canopen.c canopen_utils.c stm32_motor.c robot_event.c StepAxisObj.c
  group Modbus
    ./Modbus/: bsp_timer.c bsp.c modbus_host.c bsp_uart_fifo.c bsp_user_lib.c
